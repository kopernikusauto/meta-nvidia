include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "7c0ac1a2e608d4fb79d2f29f1073897f"
SRC_URI[sha256sum] = "00d46ffaf3e1e430081ddbd68b74cc361cd1328e8944224dfe69630dd8540f17"
